# Keil uVision project rtx407.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtx407
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: redLed_thread.c greenLed_thread.c orangeLed_thread.c blueLed_thread.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS:Keil RTX 4.81.1, Device:STM32Cube HAL:Common 1.7.3, Device:STM32Cube HAL:Cortex 1.7.3, Device:STM32Cube HAL:GPIO 1.7.3, Device:STM32Cube HAL:PWR 1.7.3, Device:STM32Cube HAL:RCC 1.7.3, Device:Startup 2.6.2
